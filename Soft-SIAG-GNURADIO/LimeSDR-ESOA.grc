options:
  parameters:
    generate_options: qt_gui
    id: top_block_fm_completo
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: AUD_GAIN
  id: variable_qtgui_range
  parameters:
    label: Audio gain
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1'
    widget: dial
  states: {}
- name: Fc_1F
  id: variable
  parameters:
    value: '0'
  states: {}
- name: RX_FREQ_COARSE
  id: variable_qtgui_range
  parameters:
    start: '40000000'
    step: '100000'
    stop: '3000000000'
    value: '916000000'
  states: {}
- name: RX_FREQ_FINE
  id: variable_qtgui_range
  parameters:
    start: '-100000'
    step: '1'
    stop: '100000'
    value: '0'
  states: {}
- name: TX_FREQ_COARSE
  id: variable_qtgui_range
  parameters:
    start: '140000000'
    step: '100000'
    stop: '3000000000'
    value: '916000000'
  states: {}
- name: TX_FREQ_FINE
  id: variable_qtgui_range
  parameters:
    start: '-100000'
    step: '1'
    stop: '100000'
    value: '0'
  states: {}
- name: audio_vol
  id: variable_qtgui_range
  parameters:
    label: Volumen
    start: '0'
    step: '0.05'
    stop: '4'
    value: '0'
    widget: dial
  states: {}
- name: func_probe_rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: function_probe_SINAD
  id: variable_function_probe
  parameters:
    block_id: epy_block_sinad
    function_name: get_SINAD
    poll_rate: func_probe_rate
    value: '0'
  states: {}
- name: function_probe_SINAD_ND
  id: variable_function_probe
  parameters:
    block_id: epy_block_sinad
    function_name: get_ND
    poll_rate: func_probe_rate
    value: '0'
  states: {}
- name: function_probe_SINAD_SND
  id: variable_function_probe
  parameters:
    block_id: epy_block_sinad
    function_name: get_SND
    poll_rate: func_probe_rate
    value: '0'
  states: {}
- name: function_probe_SNR
  id: variable_function_probe
  parameters:
    block_id: epy_block_SNR
    function_name: get_SNR
    poll_rate: func_probe_rate
    value: '0'
  states: {}
- name: function_probe_SNR_ND
  id: variable_function_probe
  parameters:
    block_id: epy_block_SNR
    function_name: get_ND
    poll_rate: func_probe_rate
    value: '0'
  states: {}
- name: function_probe_SNR_S
  id: variable_function_probe
  parameters:
    block_id: epy_block_SNR
    function_name: get_S
    poll_rate: func_probe_rate
    value: '0'
  states: {}
- name: label_SINAD
  id: variable_qtgui_label
  parameters:
    label: SINAD
    type: raw
    value: '0'
  states: {}
- name: label_SINAD_ND
  id: variable_qtgui_label
  parameters:
    label: SINAD (Noise + Distortion)
    type: raw
    value: '0'
  states: {}
- name: label_SINAD_SND
  id: variable_qtgui_label
  parameters:
    label: SINAD (Signal + Noise + Distortion)
    type: raw
    value: '0'
  states: {}
- name: label_SNR
  id: variable_qtgui_label
  parameters:
    label: SNR
    type: raw
    value: '0'
  states: {}
- name: label_SNR_ND
  id: variable_qtgui_label
  parameters:
    label: SNR (Noise + Distortion)
    type: raw
    value: '0'
  states: {}
- name: label_SNR_S
  id: variable_qtgui_label
  parameters:
    label: SNR (Signal)
    type: raw
    value: '0'
  states: {}
- name: label_pot_RX
  id: variable_qtgui_label
  parameters:
    label: Gain [dB]
    type: raw
    value: '0'
  states: {}
- name: label_pot_TX
  id: variable_qtgui_label
  parameters:
    label: Gain [dB]
    type: raw
    value: '45'
  states: {}
- name: movil_avg
  id: variable
  parameters:
    value: '50'
  states: {}
- name: pb_push_to_talk
  id: variable_qtgui_push_button
  parameters:
    label: PUSH TO TALK
    pressed: '1'
    released: '0'
    type: raw
    value: '0'
  states: {}
- name: q_filter
  id: variable
  parameters:
    value: '40'
  states: {}
- name: rb_control
  id: variable_qtgui_chooser
  parameters:
    label: OPTIONS
    label0: Full Duplex
    label1: Push to Talk
    label2: Test
    num_opts: '3'
    option0: '101'
    option1: '102'
    option2: '103'
    orient: Qt.QHBoxLayout
    type: raw
    value: '101'
    widget: radio_buttons
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '60'
    value: '0'
    widget: dial
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate_mult
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '73'
    value: '45'
    widget: dial
  states: {}
- name: variable_qtgui_label_3
  id: variable_qtgui_label
  parameters:
    type: int
    value: '0'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '10'
    audio_pass: '3000'
    audio_stop: '4000'
    chan_rate: samp_rate_mult
    deviation: '5000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '0.6545'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {bus_sink: true, state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '5000'
    low_cutoff_freq: '200'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: movil_avg
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from scipy import signal
      from gnuradio import gr

      class sinad_calculator(gr.sync_block):
          """
          Bloque de GNU Radio personalizado para calcular la relación SINAD (Signal-to-Noise
          and Distortion).

          Utiliza un filtro Notch IIR para atenuar la señal principal y medir la
          potencia del ruido y la distorsión. La potencia total se mide antes del filtro.
          Se aplica un promedio móvil a las mediciones de potencia para mayor estabilidad.

          Parámetros:
          - sample_rate: Frecuencia de muestreo de la señal de entrada (Hz).
          - signal_freq: Frecuencia de la señal principal a medir (Hz).
          - num_samples: Número de muestras por bloque para el cálculo de potencia.
          - q_param: Factor Q del filtro Notch IIR (determina la selectividad del filtro).
          - mov_avg_len: Longitud del promedio móvil para las mediciones de potencia.
          """
          def __init__(self, sample_rate=48000.0, signal_freq=1000.0, num_samples=1024, q_param=40.0, mov_avg_len=50):
              # Inicializa el bloque síncrono de GNU Radio.
              # Una entrada (float), una salida (float para SINAD en dB).
              gr.sync_block.__init__(
                  self,
                  name='SINAD',
                  in_sig=[np.float32], # Asumimos entrada float. Cambiar a np.complex64 si la señal es compleja.
                  out_sig=[np.float32] # Salida SINAD en dB
              )

              # Guarda los parámetros del bloque
              self.sample_rate = float(sample_rate)
              self.signal_freq = float(signal_freq)
              self.num_samples = int(num_samples)
              self.q_param = float(q_param)
              self.mov_avg_len = int(mov_avg_len)

              # Asegura que la longitud del promedio móvil sea al menos 1
              if self.mov_avg_len < 1:
                  self.mov_avg_len = 1

              # Historial para el promedio móvil de la potencia total (S+N+D)
              self.power_total_history = np.zeros(self.mov_avg_len)
              self.power_total_idx = 0

              # Historial para el promedio móvil de la potencia de ruido y distorsión (N+D)
              self.power_nd_history = np.zeros(self.mov_avg_len)
              self.power_nd_idx = 0

              # Diseña el filtro Notch IIR
              # El filtro Notch se usará para eliminar la señal principal y así medir N+D.
              try:
                  self.b_notch, self.a_notch = signal.iirnotch(
                      self.signal_freq, self.q_param, self.sample_rate
                  )
              except ValueError as e:
                  # Manejo de errores si los parámetros del filtro no son válidos
                  print(f"Error al diseñar el filtro Notch: {e}")
                  # Establece coeficientes de paso directo para evitar errores en work()
                  self.b_notch = np.array([1.0])
                  self.a_notch = np.array([1.0])

              # Estado del filtro Notch (para mantener la continuidad entre llamadas a work)
              self.zi_notch = signal.lfilter_zi(self.b_notch, self.a_notch) * 0.0


          def work(self, input_items, output_items):
              # Obtiene el buffer de entrada y salida
              in0 = input_items[0]
              out0 = output_items[0]

              # Asegura que tenemos suficientes muestras para procesar
              if len(in0) < self.num_samples:
                  return 0 # No hay suficientes muestras para un cálculo completo

              # Procesar en bloques de num_samples
              num_output_items = len(out0)
              processed_samples = 0

              for i in range(0, len(in0), self.num_samples):
                  current_block = in0[i : i + self.num_samples]

                  if len(current_block) < self.num_samples:
                      break # El último bloque puede ser más pequeño, lo ignoramos por ahora

                  # 1. Calcular la potencia total (S+N+D) del bloque actual
                  # Para señales reales: potencia = media(abs(señal)^2)
                  power_total_current = np.mean(np.abs(current_block)**2)

                  # Actualizar el historial del promedio móvil para la potencia total
                  self.power_total_history[self.power_total_idx] = power_total_current
                  self.power_total_idx = (self.power_total_idx + 1) % self.mov_avg_len
                  avg_power_total = np.mean(self.power_total_history)

                  # 2. Aplicar el filtro Notch IIR para obtener solo Ruido + Distorsión (N+D)
                  # Usamos lfilter y mantenemos el estado (zi) para continuidad
                  filtered_nd_signal, self.zi_notch = signal.lfilter(
                      self.b_notch, self.a_notch, current_block, zi=self.zi_notch
                  )

                  # 3. Calcular la potencia de Ruido + Distorsión (N+D)
                  power_nd_current = np.mean(np.abs(filtered_nd_signal)**2)

                  # Actualizar el historial del promedio móvil para la potencia N+D
                  self.power_nd_history[self.power_nd_idx] = power_nd_current
                  self.power_nd_idx = (self.power_nd_idx + 1) % self.mov_avg_len
                  avg_power_nd = np.mean(self.power_nd_history)

                  # 4. Calcular SINAD
                  sinad_val_linear = 0.0
                  if avg_power_nd > 1e-12: # Evitar división por cero o valores muy pequeños
                      sinad_val_linear = avg_power_total / avg_power_nd
                  else:
                      # Si N+D es muy bajo, SINAD es muy alto (idealmente infinito)
                      sinad_val_linear = 1e12 # Un valor grande para representar "infinito"

                  sinad_db = 10 * np.log10(sinad_val_linear)

                  # Asigna el valor de SINAD a la salida
                  # Cada bloque de num_samples de entrada produce 1 valor de SINAD
                  if processed_samples < num_output_items:
                      out0[processed_samples] = sinad_db
                      processed_samples += 1
                  else:
                      break # Ya hemos llenado el buffer de salida

              return processed_samples # Retorna el número de muestras de salida producidas
    mov_avg_len: '50'
    num_samples: '1000'
    q_param: '40'
    sample_rate: samp_rate
    signal_freq: ''
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from scipy import signal
      from gnuradio import gr

      class snr_calculator(gr.sync_block):
          """
          Bloque de GNU Radio personalizado para calcular la relación SNR (Signal-to-Noise Ratio).

          Utiliza un filtro Pasa-Banda para aislar la señal (S) y un filtro Notch IIR
          para aislar el ruido (N). Se aplica un promedio móvil a las mediciones de potencia.

          Parámetros:
          - sample_rate: Frecuencia de muestreo de la señal de entrada (Hz).
          - signal_freq: Frecuencia de la señal principal a medir (Hz).
          - num_samples: Número de muestras por bloque para el cálculo de potencia.
          - q_notch: Factor Q del filtro Notch IIR (para aislar N).
          - q_bp: Factor Q del filtro Pasa-Banda IIR (para aislar S).
          - mov_avg_len: Longitud del promedio móvil para las mediciones de potencia.
          """
          def __init__(self, sample_rate=48000.0, signal_freq=1000.0, num_samples=1024, q_notch=40.0, q_bp=40.0, mov_avg_len=50):
              # Inicializa el bloque síncrono de GNU Radio.
              # Una entrada (float), una salida (float para SNR en dB).
              gr.sync_block.__init__(
                  self,
                  name='SNR',
                  in_sig=[np.float32], # Asumimos entrada float. Cambiar a np.complex64 si la señal es compleja.
                  out_sig=[np.float32] # Salida SNR en dB
              )

              # Guarda los parámetros del bloque
              self.sample_rate = float(sample_rate)
              self.signal_freq = float(signal_freq)
              self.num_samples = int(num_samples)
              self.q_notch = float(q_notch)
              self.q_bp = float(q_bp)
              self.mov_avg_len = int(mov_avg_len)

              # Asegura que la longitud del promedio móvil sea al menos 1
              if self.mov_avg_len < 1:
                  self.mov_avg_len = 1

              # Historial para el promedio móvil de la potencia de la señal (S)
              self.power_s_history = np.zeros(self.mov_avg_len)
              self.power_s_idx = 0

              # Historial para el promedio móvil de la potencia del ruido (N)
              self.power_n_history = np.zeros(self.mov_avg_len)
              self.power_n_idx = 0

              # Diseña el filtro Notch IIR (para aislar el ruido)
              try:
                  self.b_notch, self.a_notch = signal.iirnotch(
                      self.signal_freq, self.q_notch, self.sample_rate
                  )
              except ValueError as e:
                  print(f"Error al diseñar el filtro Notch para SNR: {e}")
                  self.b_notch = np.array([1.0])
                  self.a_notch = np.array([1.0])

              # Diseña el filtro Pasa-Banda IIR (para aislar la señal)
              # Se crea una banda de paso estrecha alrededor de signal_freq
              nyquist = 0.5 * self.sample_rate
              lowcut = (self.signal_freq - (self.signal_freq / (2 * self.q_bp))) / nyquist
              highcut = (self.signal_freq + (self.signal_freq / (2 * self.q_bp))) / nyquist
              
              # Asegurarse de que las frecuencias de corte sean válidas
              if lowcut < 0: lowcut = 0.01 # Evitar frecuencia negativa
              if highcut >= 1: highcut = 0.99 # Evitar o exceder la frecuencia de Nyquist

              try:
                  # 'bandpass' para un filtro pasa-banda
                  self.b_bp, self.a_bp = signal.iirfilter(
                      N=4,  # Orden del filtro, puedes ajustarlo
                      Wn=[lowcut, highcut],
                      btype='bandpass',
                      ftype='butter', # Tipo de filtro, Butterworth es común
                      fs=self.sample_rate
                  )
              except ValueError as e:
                  print(f"Error al diseñar el filtro Pasa-Banda para SNR: {e}")
                  self.b_bp = np.array([1.0])
                  self.a_bp = np.array([1.0])

              # Estados de los filtros (para mantener la continuidad entre llamadas a work)
              self.zi_notch = signal.lfilter_zi(self.b_notch, self.a_notch) * 0.0
              self.zi_bp = signal.lfilter_zi(self.b_bp, self.a_bp) * 0.0


          def work(self, input_items, output_items):
              # Obtiene el buffer de entrada y salida
              in0 = input_items[0]
              out0 = output_items[0]

              # Asegura que tenemos suficientes muestras para procesar
              if len(in0) < self.num_samples:
                  return 0 # No hay suficientes muestras para un cálculo completo

              # Procesar en bloques de num_samples
              num_output_items = len(out0)
              processed_samples = 0

              for i in range(0, len(in0), self.num_samples):
                  current_block = in0[i : i + self.num_samples]

                  if len(current_block) < self.num_samples:
                      break # El último bloque puede ser más pequeño, lo ignoramos por ahora

                  # 1. Aísla la señal (S) usando el filtro Pasa-Banda
                  filtered_s_signal, self.zi_bp = signal.lfilter(
                      self.b_bp, self.a_bp, current_block, zi=self.zi_bp
                  )
                  power_s_current = np.mean(np.abs(filtered_s_signal)**2)

                  # Actualizar el historial del promedio móvil para la potencia de la señal
                  self.power_s_history[self.power_s_idx] = power_s_current
                  self.power_s_idx = (self.power_s_idx + 1) % self.mov_avg_len
                  avg_power_s = np.mean(self.power_s_history)

                  # 2. Aísla el ruido (N) usando el filtro Notch (elimina la señal principal)
                  filtered_n_signal, self.zi_notch = signal.lfilter(
                      self.b_notch, self.a_notch, current_block, zi=self.zi_notch
                  )
                  power_n_current = np.mean(np.abs(filtered_n_signal)**2)

                  # Actualizar el historial del promedio móvil para la potencia del ruido
                  self.power_n_history[self.power_n_idx] = power_n_current
                  self.power_n_idx = (self.power_n_idx + 1) % self.mov_avg_len
                  avg_power_n = np.mean(self.power_n_history)

                  # 3. Calcular SNR
                  snr_val_linear = 0.0
                  if avg_power_n > 1e-12: # Evitar división por cero o valores muy pequeños
                      snr_val_linear = avg_power_s / avg_power_n
                  else:
                      # Si el ruido es muy bajo, SNR es muy alto (idealmente infinito)
                      snr_val_linear = 1e12 # Un valor grande para representar "infinito"

                  snr_db = 10 * np.log10(snr_val_linear)

                  # Asigna el valor de SNR a la salida
                  if processed_samples < num_output_items:
                      out0[processed_samples] = snr_db
                      processed_samples += 1
                  else:
                      break # Ya hemos llenado el buffer de salida

              return processed_samples # Retorna el número de muestras de salida producidas
    mov_avg_len: movil_avg
    num_samples: '1000'
    q_bp: q_filter
    q_notch: q_filter
    sample_rate: samp_rate
    signal_freq: ''
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    alias: limesdr_sink_0
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    comment: VERIFICAR NUMERO DE PLACA DE LIME SDR
    dacVal: '125'
    digital_bandw_ch0: samp_rate_mult/2
    digital_bandw_ch1: '0'
    gain_dB_ch0: tx_gain
    gain_dB_ch1: '30'
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: TX_FREQ_COARSE+TX_FREQ_FINE
    samp_rate: samp_rate_mult
    serial: 0009061c01502103
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    alias: limesdr_source_0
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 5e6
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    comment: VERIFICAR NUMERO DE PLACA
    dacVal: '125'
    digital_bandw_ch0: samp_rate_mult/2
    digital_bandw_ch1: '0'
    gain_dB_ch0: rx_gain
    gain_dB_ch1: '30'
    oversample: '0'
    rf_freq: RX_FREQ_COARSE+RX_FREQ_FINE
    samp_rate: samp_rate_mult
    serial: 0009061C01502103
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: '1'
    gain: '0.2'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: movil_avg
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_mult
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: SIGNAL+NOISE+DISTORTION
    label1: SIGNAL
    label2: NOISE+DISTORTION
    num_tabs: '3'
  states: {}
- name: qtgui_tab_widget_1
  id: qtgui_tab_widget
  parameters:
    label0: FREQ
    label1: TIME
    num_tabs: '2'
  states: {}
- name: qtgui_tab_widget_2
  id: qtgui_tab_widget
  parameters:
    label0: FREQ
    label1: TIME
    num_tabs: '2'
  states: {}
- name: qtgui_tab_widget_3
  id: qtgui_tab_widget
  parameters:
    label0: FREQ
    label1: TIME
    num_tabs: '2'
  states: {}
- name: qtgui_tab_widget_4
  id: qtgui_tab_widget
  parameters:
    label0: SINAD
    num_tabs: '1'
  states: {}
- name: qtgui_tab_widget_5
  id: qtgui_tab_widget
  parameters:
    label0: Push to Talk
    num_tabs: '1'
  states: {}
- name: qtgui_tab_widget_6
  id: qtgui_tab_widget
  parameters:
    label0: TX CONTROL
    num_tabs: '1'
  states: {}
- name: qtgui_tab_widget_7
  id: qtgui_tab_widget
  parameters:
    label0: RX CONTROL
    num_tabs: '1'
  states: {}
- name: qtgui_tab_widget_8
  id: qtgui_tab_widget
  parameters:
    label0: SNR
    num_tabs: '1'
  states: {}
- name: qtgui_tab_widget_9
  id: qtgui_tab_widget
  parameters:
    label0: CONTROL
    num_tabs: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    type: ccc
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_fm_demod_cf_0, '0', epy_block_0, '0']
- [analog_fm_demod_cf_0, '0', epy_block_1, '0']
- [analog_fm_demod_cf_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_fm_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_fm_preemph_0, '0', analog_frequency_modulator_fc_0, '0']
- [analog_frequency_modulator_fc_0, '0', low_pass_filter_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [band_pass_filter_0, '0', analog_fm_preemph_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_throttle_0, '0', band_pass_filter_0, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_1, '0']
- [epy_block_0, '0', qtgui_time_sink_x_1, '0']
- [epy_block_1, '0', qtgui_freq_sink_x_2, '0']
- [epy_block_1, '0', qtgui_time_sink_x_2, '0']
- [limesdr_source_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_1, '0', analog_fm_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', limesdr_sink_0, '0']

metadata:
  file_format: 1
